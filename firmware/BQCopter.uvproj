# Keil uVision project BQCopter.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BQCopter +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --cpp
  c include: .\;.\src;.\src\startups;.\lib\SPL\inc;.\lib\SPL\src;.\lib\CMSIS\CoreSupport;.\lib\CMSIS\DeviceSupport\ST\STM32F10x;.\src\vendor
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./src/startups/: startup_stm32f10x_md.s
  group SourceFiles
    ./src/: ADXL345.c ESC.c I2C.c L3G4200D.c main.c SPI.c HMC5883L.c extended_math.c time.c UART.c RF24.cpp
    ./src/vendor/: MadgwickAHRS.c
  group CMSIS
    ./lib/CMSIS/CoreSupport/: core_cm3.c
    ./lib/CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group SPL
    ./lib/SPL/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group HeaderFiles
    ./src/: ADXL345.h ESC.h I2C.h L3G4200D.h SPI.h HMC5883L.h extended_math.h time.h UART.h nRF24L01.h RF24.h RF24_config.h CircularBuffer.h
    ./src/vendor/: MadgwickAHRS.h
